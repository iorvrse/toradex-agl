FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Add-default-1080p-resolution-to-fix-AGL-UI.patch"

